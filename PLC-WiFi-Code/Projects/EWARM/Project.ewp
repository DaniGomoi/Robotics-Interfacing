# IAR project Project.ewp, settings and files
configuration PLC01A1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; USE_STM32F4XX_NUCLEO; USART_PRINT_MSG; PLC01A1
  ICCARM.CCIncludePath2: ..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\Drivers\BSP\STM32F4xx-Nucleo; ..\..\Drivers\BSP\X-NUCLEO-MODULES; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\..\Drivers\BSP\Components; ..\..\Drivers\Middlewear; ..\..\Drivers\BSP\Common; ..\..\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration OUT01A1 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; USE_STM32F4XX_NUCLEO; USART_PRINT_MSG; OUT01A1
configuration PLC01A1_OUT01A1 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; USE_STM32F4XX_NUCLEO; USART_PRINT_MSG; PLC01A1_OUT01A1
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../Drivers/BSP/Components/: CLT01_38S.c ISO8200BQ.c VNI8200XP.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-MODULES
    ../Src/: PLC_Handling.c
    ../../Drivers/BSP/X-NUCLEO-MODULES/: ring_buffer.c stm32_spwf_wifi.c wifi_interface.c wifi_module.c X_NUCLEO_01A1.c X_NUCLEO_PLC01A1.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/Middleware
    ../../Drivers/Middlewear/: Ladder_Lib.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group Example/EWARM
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xe.s
  group Example/User
    ../Src/: main.c stm32_xx_it.c
